ELETTRA_ACCOUNTS:append = " \
    giulio.gaio \
    graziano.scalamera \
    claudio.scafuri \
    alessandro.abrami \
    martin.scarcia \
    adriano.contillo \
    "
