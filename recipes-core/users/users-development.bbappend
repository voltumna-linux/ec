ELETTRA_SUDO_ACCOUNTS = " \
    lorenzo.pivetta \
    alessio.bogani \
    "
