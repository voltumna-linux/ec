PACKAGECONFIG:append = " telemetry"
