PACKAGECONFIG:remove = "python"
