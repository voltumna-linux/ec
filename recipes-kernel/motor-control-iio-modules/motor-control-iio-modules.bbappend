FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-drivers-adapt-callbacks-to-the-6.6-kernel-API.patch"