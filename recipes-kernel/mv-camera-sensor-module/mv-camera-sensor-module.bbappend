FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-imx547-use-video-ops-for-frame-interval-callbacks.patch"
